CORE_IMAGE_EXTRA_INSTALL:remove = "kernel-module-bdsdmac-backports" 
