
SRC_URI:remove = "http://archive.apache.org/dist/excalibur/avalon-framework/source/${BP}-src.tar.gz;name=archive"
SRC_URI:append = " http://archive.apache.org/dist/excalibur/excalibur-framework/source/${BP}-src.tar.gz;name=archive"
