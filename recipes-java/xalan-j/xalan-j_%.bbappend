
SRC_URI:remove = "http://archive.apache.org/dist/xml/${BPN}/${BPN}_2_7_1-src.tar.gz;name=archive"
SRC_URI:append = " http://archive.apache.org/dist/xml/${BPN}/source/${BPN}_2_7_1-src.tar.gz;name=archive"
