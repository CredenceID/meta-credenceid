
SRC_URI:remove = "http://archive.apache.org/dist/xml/commons/xml-commons-resolver-${PV}.tar.gz"
SRC_URI:append = " https://downloads.apache.org/xerces/xml-commons/xml-commons-resolver-${PV}.tar.gz" 

