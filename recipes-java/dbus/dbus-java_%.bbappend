EXTRA_OEMAKE:append = " JCFLAGS='-source 1.8 ${JCFLAGS}'"

